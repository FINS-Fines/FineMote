# Keil uVision project Robomaster_A.uvprojx, settings and files
target Robomaster_A (6240000::V6.24::ARMCLANG)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Robomaster_A +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: USE_HAL_DRIVER,STM32F427xx,__ROBOMASTER_A,__KEIL_APP
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../FineMote_BSP;../../../Interface;../../../Services;../../../Devices;../../../Algorithms;../../../Components;../../../ThirdParty/etl/include;..;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;..\..\..\ThirdParty\FreeRTOS-POSIX\FreeRTOS-Plus-POSIX\include;..\..\..\ThirdParty\FreeRTOS-POSIX\FreeRTOS-Plus-POSIX\include\portable;..\..\..\ThirdParty\FreeRTOS-POSIX\include;..\..\..\ThirdParty\FreeRTOS-POSIX\include\private;..\Middlewares\Third_Party\FreeRTOS_POSIX
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c iwdg.c spi.c tim.c usart.c usb_otg.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BSP
    ../: Semihost.c Robomaster_A.cpp
    ../FineMote_BSP/: BSP_CAN.cpp BSP_DSHOT.cpp BSP_PWM.cpp BSP_RS485.cpp BSP_UART.cpp
  group Interface
    ../../../Interface/: Interface.cpp Task.cpp
    ../../../Interface/UserTasks/: UserTask1.cpp
    ../../../Interface/Examples/: TaskBeepMusic.cpp TaskLED.cpp TaskPOVChassis.cpp
  group Algorithms
    ../../../Algorithms/Matrix/: matrix.cpp
    ../../../Algorithms/Verification/: CRC.cpp
  group Services
    ../../../Services/MultiMedia/: BeepMusic.cpp
    ../../../Services/Bus/: I2C_Base.cpp
  group Devices
    ../../../Devices/: DeviceBase.cpp
    ../../../Devices/RemoteControllers/: RadioMaster_Zorro.cpp RemoteControl.cpp
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
